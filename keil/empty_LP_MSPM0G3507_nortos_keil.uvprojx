# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __MSPM0G3507__
  c include: ../../source/third_party/CMSIS/Core/Include;../../source;..\Hardware;..\Public;..\Hardware\LCD;..\Public\Board;..\Hardware\CONTROL;..\..\GyroPID;D:\TI\mspm0_sdk_2_02_00_05\source;D:\TI\mspm0_sdk_2_02_00_05\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: D:\TI\mspm0_sdk_2_02_00_05\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c main.c boot_config.h
    ./: startup_mspm0g350x_uvision.s
  group Application
    ../Application/: RobotPlatform.c RobotPlatform.h RouteNavigator.c RouteNavigator.h StatusSignal.c StatusSignal.h Task3_LinkedOperation.c Task3_LinkedOperation.h Task1_AutoTrace.c Task1_AutoTrace.h TaskBonusFourLap.c TaskBonusFourLap.h TaskBonus1_LaserTrace.c TaskBonus1_LaserTrace.h
  group Hardware
    ../Hardware/: Encoder.c Motor.c IMU.c Gray.c Buzzer.c Buzzer.h LaserRelay.c LaserRelay.h TrackZone.c TrackZone.h Bluetooth.c
    ../Hardware/CONTROL/: SpeedPI.c GrayTrack.c HeadingControl.c control.c
    ../: boot_config.c
  group Public
    ../Public/Board/: board.c
